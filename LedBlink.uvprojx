# Keil uVision project LedBlink.uvprojx, settings and files
target N32WB03X (6240000::V6.24::ARMCLANG)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03x_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: LedBlink +hex
  AfterMake: fromelf --bin --output=.\bin\LedBlink.bin .\Objects\LedBlink.axf
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32WB03X, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb03x_std_periph_driver\inc
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../../../../firmware/n32wb03x_std_periph_driver/src/: n32wb03x_gpio.c n32wb03x_rcc.c
  group USER
    ../src/: main.c n32wb03x_it.c
  group DOC
    ../: readme.txt
